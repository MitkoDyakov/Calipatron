<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\caliperBringup.ewp</path>
    </project>
    <project>
        <path>C:\Users\Workstation\Documents\Test\EWARM\Test.ewp</path>
    </project>
    <batchBuild />
</workspace>
